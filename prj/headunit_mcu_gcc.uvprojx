# Keil uVision project headunit_mcu_gcc.uvprojx, settings and files
target stm32l052k_headunit_mcu (ARM-GNU)
  device: STM32L052K8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ..\bin\fw.elf
  group board
    ../src/: board.c main.c input_encoders.c input_keys.c i2c_hci.c
  group framework
    ../../../framework/os/: startup.c osfunc.c irq-core.c
    ../../../framework/hal/common/: svcall.c systick.c
    ../../../framework/hal/stm32l0/: mcu.c irq.c gpio.c clock.c dma.c
    ../../../framework/utils/: heap.c memory.c
